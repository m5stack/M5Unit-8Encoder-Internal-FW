# Keil uVision project basex_bootloader.uvprojx, settings and files
target basex_bootloader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: basex_bootloader +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o .\basex_bootloader\basex_bootloader.bin .\basex_bootloader\basex_bootloader.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=0,DATA_CACHE_ENABLE=0,STM32F030x8
  c include: ../Core/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f030x8.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f0xx_it.c stm32f0xx_flash.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_gpio.c stm32f0xx_ll_i2c.c stm32f0xx_ll_dma.c stm32f0xx_ll_rcc.c stm32f0xx_ll_utils.c stm32f0xx_ll_exti.c stm32f0xx_ll_pwr.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
software components: CMSIS:CORE 4.3.0
